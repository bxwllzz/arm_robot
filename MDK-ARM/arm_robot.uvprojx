# Keil uVision project arm_robot.uvprojx, settings and files
target arm_robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: arm_robot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --cpp11
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ../Drivers/BSP;  ../Drivers/BMX055;  ../SEGGER_RTT;  ../rosserial
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c
  group Drivers/BSP
    ../Drivers/BSP/: button.cpp servo.cpp high_resolution_clock.c
  group Drivers/BMX055
    ../Drivers/BMX055/: bma2x2.c bmg160.c bmm050.c bmx055.cpp
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/rosserial
    ../rosserial/: duration.cpp time.cpp
  group Application/SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c
  group Application/User
    ../Src/: stm32f1xx_it.c gpio.c stm32f1xx_hal_msp.c adc.c dma.c tim.c usart.c i2c.c can.c main.c main_cpp.cpp
software components: CMSIS:CORE 5.1.1
